#include "node_display.h"

#include "node_logic.h"

#include <string.h>

/* 5×7, kolumn för kolumn, bit 0 är överst. Tecken 32–90. */
static const uint8_t font_5x7[][5] = {
    { 0x00, 0x00, 0x00, 0x00, 0x00 },
    { 0x00, 0x00, 0x5F, 0x00, 0x00 },
    { 0x00, 0x07, 0x00, 0x07, 0x00 },
    { 0x14, 0x7F, 0x14, 0x7F, 0x14 },
    { 0x24, 0x2A, 0x7F, 0x2A, 0x12 },
    { 0x23, 0x13, 0x08, 0x64, 0x62 },
    { 0x36, 0x49, 0x55, 0x22, 0x50 },
    { 0x00, 0x05, 0x03, 0x00, 0x00 },
    { 0x00, 0x1C, 0x22, 0x41, 0x00 },
    { 0x00, 0x41, 0x22, 0x1C, 0x00 },
    { 0x14, 0x08, 0x3E, 0x08, 0x14 },
    { 0x08, 0x08, 0x3E, 0x08, 0x08 },
    { 0x00, 0x50, 0x30, 0x00, 0x00 },
    { 0x08, 0x08, 0x08, 0x08, 0x08 },
    { 0x00, 0x60, 0x60, 0x00, 0x00 },
    { 0x20, 0x10, 0x08, 0x04, 0x02 },
    { 0x3E, 0x51, 0x49, 0x45, 0x3E },
    { 0x00, 0x42, 0x7F, 0x40, 0x00 },
    { 0x42, 0x61, 0x51, 0x49, 0x46 },
    { 0x21, 0x41, 0x45, 0x4B, 0x31 },
    { 0x18, 0x14, 0x12, 0x7F, 0x10 },
    { 0x27, 0x45, 0x45, 0x45, 0x39 },
    { 0x3C, 0x4A, 0x49, 0x49, 0x30 },
    { 0x01, 0x71, 0x09, 0x05, 0x03 },
    { 0x36, 0x49, 0x49, 0x49, 0x36 },
    { 0x06, 0x49, 0x49, 0x29, 0x1E },
    { 0x00, 0x36, 0x36, 0x00, 0x00 },
    { 0x00, 0x56, 0x36, 0x00, 0x00 },
    { 0x08, 0x14, 0x22, 0x41, 0x00 },
    { 0x14, 0x14, 0x14, 0x14, 0x14 },
    { 0x00, 0x41, 0x22, 0x14, 0x08 },
    { 0x02, 0x01, 0x51, 0x09, 0x06 },
    { 0x32, 0x49, 0x79, 0x41, 0x3E },
    { 0x7E, 0x11, 0x11, 0x11, 0x7E },
    { 0x7F, 0x49, 0x49, 0x49, 0x36 },
    { 0x3E, 0x41, 0x41, 0x41, 0x22 },
    { 0x7F, 0x41, 0x41, 0x22, 0x1C },
    { 0x7F, 0x49, 0x49, 0x49, 0x41 },
    { 0x7F, 0x09, 0x09, 0x09, 0x01 },
    { 0x3E, 0x41, 0x49, 0x49, 0x7A },
    { 0x7F, 0x08, 0x08, 0x08, 0x7F },
    { 0x00, 0x41, 0x7F, 0x41, 0x00 },
    { 0x20, 0x40, 0x41, 0x3F, 0x01 },
    { 0x7F, 0x08, 0x14, 0x22, 0x41 },
    { 0x7F, 0x40, 0x40, 0x40, 0x40 },
    { 0x7F, 0x02, 0x0C, 0x02, 0x7F },
    { 0x7F, 0x04, 0x08, 0x10, 0x7F },
    { 0x3E, 0x41, 0x41, 0x41, 0x3E },
    { 0x7F, 0x09, 0x09, 0x09, 0x06 },
    { 0x3E, 0x41, 0x51, 0x21, 0x5E },
    { 0x7F, 0x09, 0x19, 0x29, 0x46 },
    { 0x46, 0x49, 0x49, 0x49, 0x31 },
    { 0x01, 0x01, 0x7F, 0x01, 0x01 },
    { 0x3F, 0x40, 0x40, 0x40, 0x3F },
    { 0x1F, 0x20, 0x40, 0x20, 0x1F },
    { 0x3F, 0x40, 0x38, 0x40, 0x3F },
    { 0x63, 0x14, 0x08, 0x14, 0x63 },
    { 0x07, 0x08, 0x70, 0x08, 0x07 },
    { 0x61, 0x51, 0x49, 0x45, 0x43 }
};

static int g_dirty;
static int16_t g_shown = 0x7FFF;

static void plot(uint8_t *fb, int x, int y, int on)
{
    int index;

    if (x < 0 || x >= NODE_FB_W || y < 0 || y >= NODE_FB_H) {
        return;
    }
    index = (y / 8) * NODE_FB_W + x;
    if (on) {
        fb[index] |= (uint8_t)(1u << (y & 7));
    } else {
        fb[index] &= (uint8_t)~(1u << (y & 7));
    }
}

static void glyph(uint8_t *fb, int x, int y, char ch, int scale)
{
    int col;
    int row;
    int code = (unsigned char)ch;
    const uint8_t *bits;

    if (code >= 'a' && code <= 'z') {
        code -= 32;
    }
    if (code < 32 || code > 90) {
        code = 32;
    }
    bits = font_5x7[code - 32];
    for (col = 0; col < 5; col++) {
        for (row = 0; row < 7; row++) {
            int on = (bits[col] >> row) & 1;
            int sx;
            int sy;

            for (sy = 0; sy < scale; sy++) {
                for (sx = 0; sx < scale; sx++) {
                    plot(fb, x + col * scale + sx, y + row * scale + sy, on);
                }
            }
        }
    }
}

static void text(uint8_t *fb, int x, int y, const char *s, int scale)
{
    while (*s) {
        glyph(fb, x, y, *s, scale);
        x += 6 * scale;
        s++;
    }
}

static void clear_box(uint8_t *fb, int x, int y, int w, int h)
{
    int ix;
    int iy;

    for (iy = y; iy < y + h; iy++) {
        for (ix = x; ix < x + w; ix++) {
            plot(fb, ix, iy, 0);
        }
    }
}

void display_begin(uint8_t *fb)
{
    memset(fb, 0, NODE_FB_SIZE);
    text(fb, 2, 0, NODE_POINT_NAME, 1);
    text(fb, 96, 48, "C", 1);
    g_shown = 0x7FFF;
    g_dirty = 1;
}

void display_set_c10(uint8_t *fb, int16_t c10)
{
    char digits[6];
    int whole;
    int frac;
    int neg;
    int i;

    if (c10 == g_shown) {
        return;
    }
    g_shown = c10;
    clear_box(fb, 0, 20, 96, 32);
    if (c10 == NODE_TEMP_FAULT) {
        text(fb, 4, 28, "----", 2);
        g_dirty = 1;
        return;
    }
    neg = c10 < 0;
    if (neg) {
        c10 = (int16_t)-c10;
    }
    whole = c10 / 10;
    frac = c10 % 10;
    digits[0] = neg ? '-' : ' ';
    digits[1] = (char)('0' + (whole / 10) % 10);
    digits[2] = (char)('0' + whole % 10);
    digits[3] = '.';
    digits[4] = (char)('0' + frac);
    digits[5] = 0;
    if (digits[1] == '0') {
        digits[1] = ' ';
    }
    for (i = 0; i < 5; i++) {
        glyph(fb, 2 + i * 14, 24, digits[i], 2);
    }
    g_dirty = 1;
}

int display_dirty(void)
{
    return g_dirty;
}

void display_clear_dirty(void)
{
    g_dirty = 0;
}
